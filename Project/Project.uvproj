# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Cmsis;..\App;..\ExtiDrive\USB\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Cmsis
    ../Cmsis/: core_cm3.c startup_LPC17xx.s system_LPC17xx.c
  group App
    ../App/: main.c LPC17xx_it.c
  group USB
    ../ExtiDrive/USB/src/: hiduser.c usbcore.c usbdesc.c usbhw.c usbuser.c
  group Doc
    ../Doc/: ReadMe.txt
