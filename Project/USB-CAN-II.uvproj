# Keil uVision project USB-CAN-II.uvproj, settings and files
target USB-CAN-II (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: USB-CAN-II +hex
  c flags: Optim=1
  c include: ..\ExtiDrive;..\ExtiDrive\CAN;..\ExtiDrive\UART
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Cmsis
    ./: startup_LPC17xx.s
    ../Cmsis/: core_cm3.c system_LPC17xx.c
  group App
    ../App/: LPC17xx_it.c main.c
  group BaseDrive
    ../ExtiDrive/CAN/: CAN.c
    ../ExtiDrive/UART/: uart.c
  group Doc
    ../Doc/: ReadMe.txt
  group Common
    ../Common/: error.h common.h
